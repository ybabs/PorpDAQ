# Repository ybabs/PorpDAQ (continued)

## KiCad design Hardware/board_rev1/stm32_board.kicad_pcb

Parts:
C1, C3, C4, C5, C7, C8, C10, C11, C13, C14, C15, C16, C19, C20, C21, C23, C24, C25, C26, C27, C28, C29, C31, C34, C38, C52: 100n; C_0402_1005Metric
C2, C6: 4.7u; CP_EIA-3216-18_Kemet-A
C17, C22, C51: 1u; CP_EIA-3216-18_Kemet-A
C18, C33: 1u; C_0603_1608Metric
C30, C32: 2.2u; C_1206_3216Metric
C37, C43: 10u; C_0603_1608Metric
C39, C40: 4.7p; C_0402_1005Metric
C41, C42: 1.3n; C_0603_1608Metric
C44: 100n; C_0603_1608Metric
C45, C46: 1.1n; C_0603_1608Metric
C47, C48: 1.5n; C_0603_1608Metric
C49, C50: 1n; C_0603_1608Metric
D1, D2: LED; LED_0603_1608Metric
J1: USB_B_Micro; USB_Micro-B_Molex_47346-0001
J2: PJS008-2003-1; PJS00820031; Manufacturer_Part_Number PJS008-2003-1; Mouser Part Number 945-PJS008-2003-1
J3: 142-0701-851; Manufacturer_Part_Number 142-0701-851; Mouser Part Number 530-142-0701-851
J4: Conn_01x03_Female; PinHeader_1x03_P2.54mm_Vertical
J5: Conn_01x06_Male; PinHeader_1x06_P2.54mm_Vertical
J6: Conn_01x02_Female; PinHeader_1x02_P2.54mm_Vertical
L1: FCM1608KF-601T03; L_0603_1608Metric
PS1: LD39050PU33R; SON95P300X300X100-7N-D; Manufacturer_Part_Number LD39050PU33R; Mouser Part Number 511-LD39050PU33R
R1, R2, R3, R4, R5: 47k; R_0402_1005Metric
R6, R7, R11, R15, R17, R18, R21, R22: 10k; R_0402_1005Metric
R8, R13: 0; R_0402_1005Metric
R10, R16, R19: NA; R_0402_1005Metric
R12: 510; R_0402_1005Metric
R14, R39: 100; R_0402_1005Metric
R25: 4.99k; R_0402_1005Metric
R26: 418; R_0402_1005Metric
R27: 558; R_0402_1005Metric
R28: 4.52k; R_0402_1005Metric
R32: 406; R_0402_1005Metric
R33: 541; R_0402_1005Metric
R34: 4.39k; R_0402_1005Metric
R35: 1.02k; R_0402_1005Metric
R36: 106; R_0402_1005Metric
R37: 11k; R_0402_1005Metric
R38: 966; R_0402_1005Metric
R40: 10.4k; R_0402_1005Metric
S1: TL1105CF160Q; Manufacturer_Part_Number TL1105CF160Q; Mouser Part Number 612-TL1105C
U1: STM32F746IETx; LQFP-176_24x24mm_P0.5mm
U2: AD8031ARZ-REEL; SOIC127P600X175-8N
U3, U4, U5, U6: ADA4807-1; SOT-23-6
Y1: NZ2520SB-25.600MHZ; NZ2520SB25600MHZ; Manufacturer_Part_Number NZ2520SB-25.600MHZ; Mouser Part Number N/A
Y2: Crystal; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
3V3: C21.1, C33.2, C34.2, J2.4, J5.1, PS1.4 (VOUT), R1.2, R2.2, R3.2, R4.2, R5.2, R7.2, R10.2, R11.2, R15.2, R16.2, R21.2, U2.7 (+VS), U3.6 (V+), U4.6 (V+), U5.6 (V+), U6.6 (V+), Y1.4 (VCC); also elsewhere on the board
5V: C18.2, C24.2, J1.1 (VBUS), PS1.1 (EN), PS1.6 (VIN), R6.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C10.2, C11.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.1, C19.2, C20.2, C21.2, C22.2, C23.2, C24.1, C25.2, C26.2, C27.2, C28.2, C29.2, C30.1, C31.1, C32.1, C33.1, C34.1, C37.1, C38.1, C39.2, C40.1, C43.1, C44.1, C51.2, C52.2, D1.1 (K), D2.1 (K), J1.4 (ID), J1.5 (GND), J1.6 (Shield), J2.6, J2.SH1, J2.SH2, J2.SH3, J2.SH4, J2.SW2, J3.1, J3.3, J4.3, J5.3, J6.2, PS1.2 (GND), PS1.7 (PAD), R17.2, R18.2, R19.2, R22.1, S1.2, S1.3, U1.14 (VSS), U1.22 (VSS), U1.37 (VSSA), U1.61 (VSS), U1.71 (VSS), U1.90 (VSS), U1.102 (VSS), U1.113 (VSS), U1.126 (VSS), U1.135 (VSS), U1.148 (VSS), U1.158 (VSS), U2.4 (-VS), U3.2 (V-), U4.2 (V-), U5.2 (V-)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
NRST: C31.2, J5.5, R11.1, S1.1, S1.4, U1.31 (NRST)
unnamed: C30.2, U1.81 (VCAP_1)
unnamed: C32.2, U1.125 (VCAP_2)
unnamed: C37.2, C38.2, R21.1, R22.2, U2.3 (+IN)
unnamed: C39.1, U1.9 (PC14), Y2.1
unnamed: C40.2, U1.10 (PC15), Y2.2
unnamed: C41.1, R28.2, R32.2, U3.1
unnamed: C41.2, C42.2, R26.1, R27.2
unnamed: C42.1, R28.1, U3.4 (-)
unnamed: C45.1, R34.2, R35.2, U4.1
unnamed: C45.2, C46.2, R32.1, R33.2
unnamed: C46.1, R34.1, U4.4 (-)
unnamed: C47.1, R37.2, R38.2, U5.1
unnamed: C47.2, C48.2, R35.1, R36.2
unnamed: C48.1, R37.1, U5.4 (-)
unnamed: C49.2, C50.2, R38.1, R39.2
unnamed: C50.1, R40.1, U6.4 (-)
unnamed: D1.2 (A), R6.1
unnamed: D2.2 (A), R12.1
unnamed: J2.SW1, R8.2
unnamed: J3.2, R26.2
unnamed: R7.1, Y1.1 (STAND-BY)
unnamed: R12.2, U1.132 (PI1)
unnamed: R14.1, U1.29 (PH0)
unnamed: R14.2, Y1.3 (OUTPUT)
unnamed: R15.1, R19.1, U1.171 (PDR_ON)
unnamed: R16.1, R18.1, U1.166 (BOOT0)
unnamed: R17.1, U1.48 (BYPASS_REG)
unnamed: R25.2, U2.2 (-IN)
SWCLK: J5.2, U1.137 (PA14)
SWDIO: J5.4, U1.124 (PA13)
SWO: J5.6, U1.161 (PB3)
USART6_RX: J4.2, U1.116 (PC7)
USART6_TX: J4.1, U1.115 (PC6)
VDD: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C10.1, C11.1, C13.1, C14.1, C15.1, C16.1, C17.1, C19.1, C20.1, C23.1, C25.1, C26.1, C27.1, C29.1, L1.2, U1.6 (VBAT), U1.15 (VDD), U1.23 (VDD), U1.36 (VDD), U1.49 (VDD), U1.62 (VDD), U1.72 (VDD), U1.82 (VDD), U1.91 (VDD), U1.103 (VDD), U1.114 (VDDUSB), U1.127 (VDD), U1.136 (VDD), U1.149 (VDD), U1.159 (VDD), U1.172 (VDD); also elsewhere on the board
VDDA: C22.1, C28.1, L1.1, R13.2, U1.39 (VDDA)
VREF: C43.2, C44.2, R25.1, R27.1, R33.1, R36.1, R39.1, U2.6 (OUT), U3.3 (+), U4.3 (+), U5.3 (+), U6.3 (+)
VREF+: C51.1, C52.1, R13.1, U1.38 (VREF+)
V_OUT: C49.1, J6.1, R40.2, U1.28 (PF10), U6.1
uSD_CLK: J2.5, U1.141 (PC12)
uSD_CMD: J2.3, R1.1, U1.144 (PD2)
uSD_D0: J2.7, R4.1, U1.117 (PC8)
uSD_D1: J2.8, R5.1, U1.118 (PC9)
uSD_D2: J2.1, R3.1, U1.139 (PC10)
uSD_D3: J2.2, R2.1, U1.140 (PC11)
uSD_Detect: R8.1, R10.1, U1.8 (PC13)

Notes on the sheet:
PREAMP VOLTAGE DIVIDER
PREAMP
VOLTAGE REGULATOR
USB_POWER
PWR_LED
uSD
RESET BUTTON
SWD

Notes on the sheet:
PREAMP VOLTAGE DIVIDER
uSD
PREAMP

Board: 2 copper layers, 101 parts (0 on the bottom side), 49 nets, no tracks yet.

Other parts of the board:
R20: 0; R_0402_1005Metric

Their connections:
3V3: R20.1; also elsewhere on the board
VDD: R20.2; also elsewhere on the board

## KiCad design Hardware/preamp_v2/preamp.kicad_pcb

Parts:
Battery1: Screw_Terminal_01x02; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
C1: 1uf; C_0603_1608Metric
C2: 220uF; CP_EIA-2012-15_AVX-P
C3, C4: 100nf; C_0603_1608Metric
C5, C6, C7, C8: 100pF; C_0603_1608Metric
C9: 10pF; C_0603_1608Metric
C10: 47uf; CP_EIA-2012-15_AVX-P
C11, C12, C13: 47uF; CP_EIA-2012-15_AVX-P
C14: 100nF; C_0603_1608Metric
J1: SMA-J-P-H-ST-EM1
J2, J3: Conn_01x02_Male; PinHeader_1x02_P1.00mm_Vertical
R1: 35.7k; R_0603_1608Metric
R2: 66.5k; R_0603_1608Metric
R3: 10k; R_0603_1608Metric
R4, R9: 187; R_0603_1608Metric
R5, R10: 2.49k; R_0603_1608Metric
R6: 34.8k; R_0603_1608Metric
R7: 44.2k; R_0603_1608Metric
R8: 6.34k; R_0603_1608Metric
R11, R14: 50k; R_0603_1608Metric
R12, R13: 100k; R_0603_1608Metric
R15: 330; R_0603_1608Metric
U1: TLE2426xD; SOIC-8_3.9x4.9mm_P1.27mm
U2, U3: OPA659IDBVR; SOT95P280X145-5N; Mouser Part Number 595-OPA659IDBVR
U4: LMH6643MA; SOIC127P600X175-8N
U5: LT1528CQ; DDPAK-5_Q

Connections:
B_SIG: C9.1, J3.1, R14.1, U4.1 (OUTA)
F_OUT: J2.1, R7.1, R10.1, R11.2, U3.1 (OUTPUT)
GND: C3.2, C4.2, C5.2, C8.2, C10.2, C11.2, C12.2, C13.2, C14.1, J1.2_1 (GND), J1.2_2 (GND), J1.3_1 (GND), J1.3_2 (GND), J2.2, J3.2, R3.1, R4.2, R8.1, R9.2, R13.2, R15.1, U1.1 (OUT), U4.4 (V-), U5.3 (GND_2), U5.6 (GND)
unnamed: C1.1, U1.8 (NOISE_REDUCTION)
unnamed: C5.1, C6.2, R1.1, R2.2
unnamed: C6.1, R3.2, U2.3 (POS)
unnamed: C7.1, R8.2, U3.3 (POS)
unnamed: C7.2, C8.1, R6.1, R7.2
unnamed: C9.2, R13.1, R14.2, U4.2 (-INA)
unnamed: C10.1, C11.1, C12.1, C13.1, C14.2, R12.2, R15.2, U4.8 (V+), U5.1 (OUTPUT), U5.2 (SENSE)
unnamed: J1.1 (SIGNAL), R1.2
unnamed: R2.1, R5.1, R6.2, U2.1 (OUTPUT)
unnamed: R4.1, R5.2, U2.4 (NEG)
unnamed: R9.1, R10.2, U3.4 (NEG)
unnamed: R11.1, R12.1, U4.3 (+INA)
V+: Battery1.2, C2.1, C3.1, U1.3 (IN), U2.5 (+VS), U3.5 (+VS), U5.5 (VIN)
V-: Battery1.1, C1.2, C2.2, C4.1, U1.2 (COMMON), U2.2 (-VS), U3.2 (-VS)

Board: 2 copper layers, 42 parts (0 on the bottom side), 17 nets.

Other parts of the board:
REF1, REF2, REF3, REF4: MountingHole_2.2mm_M2

## Code that names these connections

File Firmware/CustomBoard/sd_test.ioc (part):

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Mcu.Name=STM32F746VGTx
Mcu.Package=LQFP100
Mcu.UserName=STM32F746VGTx
PA13.Mode=Trace_Asynchronous_SW
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Trace_Asynchronous_SW
PA14.Signal=SYS_JTCK-SWCLK
PA3.Signal=ADCx_IN3
PB10.Signal=GPIO_Output
PB3.Mode=Trace_Asynchronous_SW
PB3.Signal=SYS_JTDO-SWO
PC10.Mode=SD_4_bits_Wide_bus
PC10.Signal=SDMMC1_D2
PC11.Mode=SD_4_bits_Wide_bus
PC11.Signal=SDMMC1_D3
PC12.Mode=SD_4_bits_Wide_bus
PC12.Signal=SDMMC1_CK
PC6.Mode=Asynchronous
PC6.Signal=USART6_TX
PC7.Mode=Asynchronous
PC7.Signal=USART6_RX
PC8.Mode=SD_4_bits_Wide_bus
PC8.Signal=SDMMC1_D0
PC9.Mode=SD_4_bits_Wide_bus
PC9.Signal=SDMMC1_D1
PD2.Mode=SD_4_bits_Wide_bus
PD2.Signal=SDMMC1_CMD
PH0/OSC_IN.Mode=HSE-External-Oscillator
PH0/OSC_IN.Signal=RCC_OSC_IN
PH1/OSC_OUT.Mode=HSE-External-Oscillator
PH1/OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=216000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

File Firmware/Non-RTOS/stm32sd.ioc (part):

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Mcu.Name=STM32F746NGHx
Mcu.Package=TFBGA216
Mcu.UserName=STM32F746NGHx
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PC10.Mode=SD_4_bits_Wide_bus
PC10.Signal=SDMMC1_D2
PC11.Mode=SD_4_bits_Wide_bus
PC11.Signal=SDMMC1_D3
PC12.Mode=SD_4_bits_Wide_bus
PC12.Signal=SDMMC1_CK
PC8.Mode=SD_4_bits_Wide_bus
PC8.Signal=SDMMC1_D0
PC9.Mode=SD_4_bits_Wide_bus
PC9.Signal=SDMMC1_D1
PD2.Mode=SD_4_bits_Wide_bus
PD2.Signal=SDMMC1_CMD
PF10.Mode=IN8
PF10.Signal=ADC3_IN8
PF6.Mode=Asynchronous
PF6.Signal=UART7_RX
PF7.Mode=Asynchronous
PF7.Signal=UART7_TX
PG6.Signal=GPIO_Output
PH0/OSC_IN.Mode=HSE-External-Oscillator
PH0/OSC_IN.Signal=RCC_OSC_IN
PH1/OSC_OUT.Mode=HSE-External-Oscillator
PH1/OSC_OUT.Signal=RCC_OSC_OUT
PI1.Signal=GPIO_Output
PI11.Signal=GPXTI11
RCC.HSE_VALUE=25000000
RCC.SYSCLKFreq_VALUE=216000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=STM32F746G-DISCO
boardIOC=true

File Firmware/PorpDaqV2/PorpDaq_V2.ioc (part):

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Mcu.Name=STM32H743ZITx
Mcu.Package=LQFP144
Mcu.UserName=STM32H743ZITx
PB10.GPIOParameters=GPIO_Label
PB10.GPIO_Label=LED_STAT
PB10.Signal=GPIO_Output
PC10.Mode=SD_4_bits_Wide_bus
PC10.Signal=SDMMC1_D2
PC11.Mode=SD_4_bits_Wide_bus
PC11.Signal=SDMMC1_D3
PC12.Mode=SD_4_bits_Wide_bus
PC12.Signal=SDMMC1_CK
PC2_C.Mode=IN0-Single-Ended
PC2_C.Signal=ADC3_INP0
PC8.Mode=SD_4_bits_Wide_bus
PC8.Signal=SDMMC1_D0
PC9.Mode=SD_4_bits_Wide_bus
PC9.Signal=SDMMC1_D1
PD2.Mode=SD_4_bits_Wide_bus
PD2.Signal=SDMMC1_CMD
PE0.Mode=Asynchronous
PE0.Signal=UART8_RX
PE1.Mode=Asynchronous
PE1.Signal=UART8_TX
PH0-OSC_IN\ (PH0).Mode=HSE-External-Oscillator
PH0-OSC_IN\ (PH0).Signal=RCC_OSC_IN
PH1-OSC_OUT\ (PH1).Mode=HSE-External-Oscillator
PH1-OSC_OUT\ (PH1).Signal=RCC_OSC_OUT
RCC.HSE_VALUE=16000000
RCC.SYSCLKFreq_VALUE=400000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2020-04-09 Initial Commit.
2020-07-02 Added F7 100 Pin Version
2020-07-14 Added 100 pin version
2020-07-23 Updated F7 100 pin schematic
2020-09-14 Edited board to add USB power
2020-09-14 Firmware added for custom board
2020-10-26 Create LICENSE
2020-11-14 Changed naming scheme of WAV files
2020-11-19 Added initial H7 Design
2020-11-24 Initial CM4IO board design
2020-11-28 Completed H7/CM4IO Board
2020-11-30 Corrected SMPS configuration
2021-01-26 Added H7 board hardware and firmware
2021-01-29 Added V2 Firmware files
2021-01-29 File rename
2021-01-29 renamed png image
2021-02-04 Commented out on H7 firmware
2021-02-24 Edited Design to modify to LDO regulator and improve board layout
2021-03-03 Added Low noise analysis and design files
2021-04-21 Fixed HSE Clock Bug and changed target to LQFP100
