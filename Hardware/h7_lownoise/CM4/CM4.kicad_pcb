# Repository ybabs/PorpDAQ

File README.md:

# PorpDAQ
STM32 Based design data acquisition recorder for harbour porpoises. The system is based on a 40dB bandpass preamplifier (90Khz - 150kHz). Records WAV file at a sampling rate of 400 KHz (V1) and 500 KHz (V2) and stores them to a microSD card. The preamplifier was designed using TI's filter designer tool. Preamp output is passed to a summing amplifier to keep signals within 0 - 3.3V with a 1.65V bias. There's a few iterations of the DAQ from the initial prototypes to improved designs. 

PorpDAQ has been designed to fit within a small multirotor UAV so current design weighs only 18g. PorpDAQ computes a 1024 point RFFT of incoming hydrophone signals and transmits signals within 90 - 150KHz over a UART Interface

## Rev 1 Board                         

The initial version of the DAQ was based on a STM32F746 chip and had a 400 KHz sample rate and a 12-bit ADC with a SD card write speed of about 20mbps. 

## Rev 2 Board

Rev 2 board comes with some improvements namely the the use of the STM32H743 chip, USB-C for power with the addition of a full speed interface. 500 KHz sample rate, SD Card write speed of ~35 Mbps with a 16-bit ADC and better SNR. Also slightly smaller footprint 
<br />

This repository mostly contains :
   - Hardware designs for the both revisions (circuits were simulated in MultiSim and designs were made in UltiBoard and Kicad)
   - Designs for the  different prototypes used.
   - A CM4-based design to integrate PorpDaq with a Pi4 Compute Module (WIP)
   - 3D designed case for the Rev 1 board 
   - Low level drivers and firmware (bare-metal version and FreeRTOS version for Rev1 and FreeRTOS version for Rev2)

## Note Rev2.1 now included as well.
  - 3.3V regulator on Rev 2 used a switcher and wasn't running in low noise mode (oops!) so 2.1 now uses a low noise ADP7156 3.3V regulator

## Structure
 - Firmware: Contains Custom Board FreeRTOS firmware and STM32F7 discovery board FreeRTOS and bare-metal firmware. Also contains H747 Disco Board firmware.  Please note bare-metal firmware currently has a UART TX bug preventing data from being transmmitted over the UART line.
 - Hardware: contains various designs and schematics for the board designs. **Rev 1** design is named `board_100pin` while  **Rev 2** design is named `h7_board`. 

 ## Citation (Bibtex)

` @article{Babatunde2020,
  doi = {10.3390/s20216064},
  url = {https://doi.org/10.3390/s20216064},
  year = {2020},
  month = oct,
  publisher = {{MDPI} {AG}},
  volume = {20},
  number = {21},
  pages = {6064},
  author = {Daniel Babatunde and Simon Pomeroy and Paul Lepper and Ben Clark and Rebecca Walker},
  title = {Autonomous Deployment of Underwater Acoustic Monitoring Devices Using an Unmanned Aerial Vehicle: The Flying Hydrophone},
  journal = {Sensors}
}`

## License
  MIT License Copyright 2020 Daniel Babatunde

## KiCad design Hardware/h7_lownoise/CM4/CM4.kicad_pcb

Parts:
FID1, FID2, FID3: Fiducial; Fiducial_0.5mm_Mask1.5mm

Parts:
C13: 4.7u; CP_EIA-3216-18_Kemet-A; LCSC Part # C7187
C14, C16, C17, C18, C20, C21, C24, C26, C34, C50: 100n; C_0402_1005Metric; LCSC Part # C1525
C15, C19: 2.2u; C_1206_3216Metric; LCSC Part # C50254
C23, C25: 1u; CP_EIA-3216-18_Kemet-A; LCSC Part # C7176
C29: 47p; C_0402_1005Metric; LCSC Part # C1567
C48, C49: 12p; C_0402_1005Metric; LCSC Part # C1547
D2: LED_Red; LED_0603_1608Metric; LCSC Part # C2286
FB2: 100 @ 100 MHz; L_0603_1608Metric; LCSC Part # C74325
J3: SWDIO; PinHeader_2x05_P1.27mm_Vertical
J4: Micro_SD_Card; microSD_HC_Hirose_DM3AT-SF-PEJM5
J7: USART; PinHeader_1x03_P2.54mm_Vertical
R17, R19, R22, R23, R24: 47k; R_0402_1005Metric; LCSC Part # C25792
R18: 0; R_0402_1005Metric; LCSC Part # C17168
R20: 47; R_0402_1005Metric; LCSC Part # C25118
R21: 2k2; R_0603_1608Metric; LCSC Part # C4190
R27: 10k; R_0402_1005Metric; LCSC Part # C25744
S1: TL1105CF160Q; Manufacturer_Part_Number TL1105CF160Q; Mouser Part Number 612-TL1105C
U2: STM32H743VITx; LQFP-100_14x14mm_P0.5mm
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC Part # C13738

Connections:
/3.3VREF: FB2.1; also elsewhere on the board
/+3.3V: C13.1, C14.1, C16.1, C17.1, C18.1, C20.1, C21.1, C34.2, J3.1, J4.4 (VDD), R17.2, R19.2, R22.2, R23.2, R24.2, U2.6 (VBAT), U2.11 (VDD), U2.27 (VDD), U2.50 (VDD), U2.75 (VDD), U2.100 (VDD); also elsewhere on the board
/H7MCU/+3.3VA: C25.1, C26.2, FB2.2, R18.2, U2.21 (VDDA)
/H7MCU/BOOT0: R27.1, U2.94 (BOOT0)
/H7MCU/HSE_IN: C49.1, U2.12 (PH0), Y1.1
/H7MCU/HSE_OUT: R20.1, U2.13 (PH1)
/H7MCU/LED_STAT: D2.2 (A), U2.46 (PB10)
/H7MCU/NRST: C50.2, J3.10, S1.1, S1.2, U2.14 (NRST)
/H7MCU/SDMMC_CK: J4.5 (CLK), U2.80 (PC12)
/H7MCU/SDMMC_CMD: J4.3 (CMD), R22.1, U2.83 (PD2)
/H7MCU/SDMMC_D0: J4.7 (DAT0), R23.1, U2.65 (PC8)
/H7MCU/SDMMC_D1: J4.8 (DAT1), R24.1, U2.66 (PC9)
/H7MCU/SDMMC_D2: J4.1 (DAT2), R17.1, U2.78 (PC10)
/H7MCU/SDMMC_D3: J4.2 (DAT3/CD), R19.1, U2.79 (PC11)
/H7MCU/SWCLK: J3.4, U2.76 (PA14)
/H7MCU/SWDIO: J3.2, U2.72 (PA13)
/H7MCU/SWO: J3.6, U2.89 (PB3)
/H7MCU/USART_RX: J7.1, U2.97 (PE0)
/H7MCU/USART_TX: J7.2, U2.98 (PE1)
/H7MCU/VREF+: C23.1, C24.2, R18.1, U2.20 (VREF+)
/P_OUT: C29.2, U2.17 (PC2_C); also elsewhere on the board
/USB_D+: U2.71 (PA12); also elsewhere on the board
/USB_D-: U2.70 (PA11); also elsewhere on the board
GND: C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C23.2, C24.1, C25.2, C26.1, C29.1, C34.1, C48.1, C49.2, C50.1, J3.3, J3.5, J3.9, J4.6 (VSS), J4.9 (SHIELD), J7.3, R21.2, R27.2, S1.3, S1.4, U2.10 (VSS), U2.19 (VSSA), U2.26 (VSS), U2.49 (VSS), U2.74 (VSS), U2.99 (VSS), Y1.2, Y1.4; also elsewhere on the board
unnamed: C15.1, U2.48 (VCAP1)
unnamed: C19.1, U2.73 (VCAP2)
unnamed: C48.2, R20.2, Y1.3
unnamed: D2.1 (K), R21.1
no_connect_58: J3.7
no_connect_59: J3.8
no_connect_60: U2.1 (PE2)
no_connect_61: U2.15 (PC0)
no_connect_62: U2.16 (PC1)
no_connect_63: U2.18 (PC3_C)
no_connect_64: U2.2 (PE3)
no_connect_65: U2.22 (PA0)
no_connect_66: U2.23 (PA1)
no_connect_67: U2.24 (PA2)
no_connect_68: U2.25 (PA3)
no_connect_69: U2.28 (PA4)
no_connect_70: U2.29 (PA5)
no_connect_71: U2.3 (PE4)
no_connect_72: U2.30 (PA6)
no_connect_73: U2.31 (PA7)
no_connect_74: U2.32 (PC4)
no_connect_75: U2.33 (PC5)
no_connect_76: U2.34 (PB0)
no_connect_77: U2.35 (PB1)
no_connect_78: U2.36 (PB2)
no_connect_79: U2.37 (PE7)
no_connect_80: U2.38 (PE8)
no_connect_81: U2.39 (PE9)
no_connect_82: U2.4 (PE5)
no_connect_83: U2.40 (PE10)
no_connect_84: U2.41 (PE11)
no_connect_85: U2.42 (PE12)
no_connect_86: U2.43 (PE13)
no_connect_87: U2.44 (PE14)
no_connect_88: U2.45 (PE15)
no_connect_89: U2.47 (PB11)
no_connect_90: U2.5 (PE6)
no_connect_91: U2.51 (PB12)
no_connect_92: U2.52 (PB13)
no_connect_93: U2.53 (PB14)
no_connect_94: U2.54 (PB15)
no_connect_95: U2.55 (PD8)
no_connect_96: U2.56 (PD9)
no_connect_97: U2.57 (PD10)
no_connect_98: U2.58 (PD11)
no_connect_99: U2.59 (PD12)
no_connect_100: U2.60 (PD13)
no_connect_101: U2.61 (PD14)
no_connect_102: U2.62 (PD15)
no_connect_103: U2.63 (PC6)
no_connect_104: U2.64 (PC7)
no_connect_105: U2.67 (PA8)
no_connect_106: U2.68 (PA9)
no_connect_107: U2.69 (PA10)
no_connect_108: U2.7 (PC13)
no_connect_109: U2.77 (PA15)
no_connect_110: U2.8 (PC14)
no_connect_111: U2.81 (PD0)
no_connect_112: U2.82 (PD1)
no_connect_113: U2.84 (PD3)
no_connect_114: U2.85 (PD4)
no_connect_115: U2.86 (PD5)
no_connect_116: U2.87 (PD6)
no_connect_117: U2.88 (PD7)
no_connect_118: U2.9 (PC15)
no_connect_119: U2.90 (PB4)
no_connect_120: U2.91 (PB5)
no_connect_121: U2.92 (PB6)
no_connect_122: U2.93 (PB7)
no_connect_123: U2.95 (PB8)
no_connect_124: U2.96 (PB9)

Notes on the sheet:
SD CARD
BOOT SELECT
HSE
RESET BUTTON

Parts:
C1, C2, C28: 10u; C_0603_1608Metric; LCSC Part # C19702
C3, C4, C5, C27: 1u; C_0603_1608Metric; LCSC Part # C15849
C22: 100n X7R; C_0603_1608Metric; LCSC Part # C14663
D3: LED; LED_0603_1608Metric; LCSC Part # C72043
F1: Polyfuse; Fuse_1206_3216Metric; LCSC Part # C369159
FB1: 600 @ 100MHz; L_0805_2012Metric; LCSC Part # C1017
IC1: ADP7156ARDZ-3.3-R7; SOIC127P600X175-9N; Manufacturer_Part_Number ADP7156ARDZ-3.3-R7; Mouser Part Number 584-ADP7156ARDZ3.3R7
J1: USB_C_Receptacle_USB2.0; TYPE-C-31-M-12; LCSC Part # C165948
Q1: AO3401A; SOT95P280X125-3N; Manufacturer_Part_Number AO3401A; LCSC Part # C15127
R1, R2: 5.1k; R_1206_3216Metric; LCSC Part # C26033
R28: 2.2k; R_0603_1608Metric; LCSC Part # C4190
U3: REF3433IDBVR
U4: USBLC6-2SC6; SOT-23-6; LCSC Part # C7519

Connections:
/3.3VREF: C28.1, U3.5 (OUT_S), U3.6 (OUT_F); also elsewhere on the board
/+3.3V: C1.1, D3.2 (A), IC1.1 (VOUT), IC1.2 (VOUT_SENSE); also elsewhere on the board
/Power/+5V: C2.1, C22.1, C27.1, FB1.2, IC1.4 (EN), IC1.8 (VIN), U3.3 (ENABLE), U3.4 (IN), U4.5 (VBUS)
/Power/USB_CONN_D+: J1.A6 (D+), J1.B6 (D+), U4.3 (I/O2)
/Power/USB_CONN_D-: J1.A7 (D-), J1.B7 (D-), U4.1 (I/O1)
/USB_D+: U4.4 (I/O2); also elsewhere on the board
/USB_D-: U4.6 (I/O1); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C22.2, C27.2, C28.2, IC1.9 (EP), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), Q1.1, R1.2, R2.2, R28.1, U3.1 (GND_F), U3.2 (GND_S), U4.2 (GND); also elsewhere on the board
unnamed: C3.1, IC1.7 (VREG)
unnamed: C4.1, IC1.3 (BYP)
unnamed: C5.1, IC1.5 (REF_SENSE), IC1.6 (REF)
unnamed: D3.1 (K), R28.2
unnamed: F1.2, Q1.3
unnamed: FB1.1, Q1.2
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.1
VCC: F1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
no_connect_56: J1.A8 (SBU1)
no_connect_57: J1.B8 (SBU2)

Notes on the sheet:
3.3V Regulator
USB C Power input and ESD Protection
ADC Voltage Reference
Reverse Polarity Protection

Parts:
C10, C12, C30, C32: 1.5n; C_0402_1005Metric; LCSC Part # C23967
C11, C31: 1.2n; C_0402_1005Metric; LCSC Part # C16529
C33, C36: 10u; C_0603_1608Metric; LCSC Part # C19702
C35, C37, C38, C39, C40, C41: 100n; C_0603_1608Metric; LCSC Part # C14663
C42: 10u; CP_EIA-3216-18_Kemet-A; LCSC Part # c7171
IC2, IC3, IC5: LT6233CS6#TRMPBF; SOT95P280X100-6N; Manufacturer_Part_Number LT6233CS6#TRMPBF; Mouser Part Number 584-LT6233CS6#TRMPBF
IC6: AD8031ARTZ-R2; SOT95P280X145-5N; Manufacturer_Part_Number AD8031ARTZ-R2; Mouser Part Number 584-AD8031ARTZ-R2
J2: Conn_Coaxial; SMA_Wurth_60312002114503_Vertical
R3, R5: 8.87k; R_0402_1005Metric; LCSC Part # C36953
R4: 4.42k; R_0402_1005Metric; LCSC Part # C52269
R6, R8: 620; R_0402_1005Metric; LCSC Part # C4961
R7: 294; R_0402_1005Metric; LCSC Part # C270618
R9, R11: 130; R_0402_1005Metric; LCSC Part # C270649
R10: 1.15k; R_0402_1005Metric; LCSC Part # C29401
R12: 4.99k; R_0603_1608Metric; LCSC Part # C23046
R13, R14: 10k; R_0603_1608Metric; LCSC Part # C25804

Connections:
/+3.3V: C38.1, C39.1, C40.1, C41.1, C42.1, IC2.6 (V+), IC3.6 (V+), IC5.6 (V+), IC6.5 (+VS), R13.1; also elsewhere on the board
/P_OUT: C12.2, IC5.1 (OUT), R5.2; also elsewhere on the board
/Preamp/+IN: C33.1, C35.1, IC6.3 (+IN), R13.2, R14.1
/Preamp/-IN1: C31.2, IC2.4 (-IN), R4.1
/Preamp/-IN2: C30.2, IC3.4 (-IN), R3.1
/Preamp/-IN3: C32.2, IC5.4 (-IN), R5.1
/Preamp/OUT1: C11.2, IC2.1 (OUT), R4.2, R6.1
/Preamp/OUT2: C10.2, IC3.1 (OUT), R3.2, R8.1
/Preamp/VREF: C36.1, C37.1, IC2.3 (+IN), IC3.3 (+IN), IC5.3 (+IN), IC6.1 (VOUT), R12.1
GND: C33.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, IC2.2 (V-), IC3.2 (V-), IC5.2 (V-), IC6.2 (-VS), J2.2 (Ext), R9.1, R10.1, R11.1, R14.2; also elsewhere on the board
unnamed: C10.1, C30.1, R6.2, R9.2
unnamed: C11.1, C31.1, R7.2, R10.2
unnamed: C12.1, C32.1, R8.2, R11.2
unnamed: IC6.4 (-IN), R12.2
unnamed: J2.1 (In), R7.1
no_connect_53: IC2.5 (~ENABLE)
no_connect_54: IC3.5 (~ENABLE)
no_connect_55: IC5.5 (~ENABLE)

Board: 4 copper layers, 68.2 x 41.6 mm, 89 parts (0 on the bottom side), 52 nets.

File Hardware/h7_lownoise/CM4/assembly/CM4-BOM.csv:

Comment,Designator,Footprint,LCSC
10u,"C1,C2,C28,C33,C36",Capacitor_SMD:C_0603_1608Metric,C19702
1.5n,"C10,C12,C30,C32",Capacitor_SMD:C_0402_1005Metric,C23967
1.2n,"C11,C31",Capacitor_SMD:C_0402_1005Metric,C16529
4.7u,C13,Capacitor_Tantalum_SMD:CP_EIA-3216-18_Kemet-A,C7187
100n,"C14,C16,C17,C18,C20,C21,C24,C26,C34,C50",Capacitor_SMD:C_0402_1005Metric,C1525
2.2u,"C15,C19",Capacitor_SMD:C_1206_3216Metric,C50254
100n X7R,C22,Capacitor_SMD:C_0603_1608Metric,C14663
1u,"C23,C25",Capacitor_Tantalum_SMD:CP_EIA-3216-18_Kemet-A,C7176
47p,C29,Capacitor_SMD:C_0402_1005Metric,C1567
1u,"C3,C4,C5,C27",Capacitor_SMD:C_0603_1608Metric,C15849
100n,"C35,C37,C38,C39,C40,C41",Capacitor_SMD:C_0603_1608Metric,C14663
10u,C42,Capacitor_Tantalum_SMD:CP_EIA-3216-18_Kemet-A,c7171
12p,"C48,C49",Capacitor_SMD:C_0402_1005Metric, C1547
LED_Red,D2,LED_SMD:LED_0603_1608Metric,C2286
LED,D3,LED_SMD:LED_0603_1608Metric,C72043
Polyfuse,F1,Fuse:Fuse_1206_3216Metric,C369159
600 @ 100MHz,FB1,Inductor_SMD:L_0805_2012Metric,C1017
100 @ 100 MHz,FB2,Inductor_SMD:L_0603_1608Metric,C74325
Fiducial,"FID1,FID2,FID3",Fiducial:Fiducial_0.5mm_Mask1.5mm,
ADP7156ARDZ-3.3-R7,IC1,SamacSys_Parts:SOIC127P600X175-9N,
LT6233CS6#TRMPBF,"IC2,IC3,IC5",SamacSys_Parts:SOT95P280X100-6N,
AD8031ARTZ-R2,IC6,SamacSys_Parts:SOT95P280X145-5N,
USB_C_Receptacle_USB2.0,J1,CM4IO:TYPE-C-31-M-12,C165948
Conn_Coaxial,J2,Connector_Coaxial:SMA_Wurth_60312002114503_Vertical,
SWDIO,J3,Connector_PinHeader_1.27mm:PinHeader_2x05_P1.27mm_Vertical,
Micro_SD_Card,J4,Connector_Card:microSD_HC_Hirose_DM3AT-SF-PEJM5,
USART,J7,Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical,
AO3401A,Q1,SamacSys_Parts:SOT95P280X125-3N, C15127
5.1k,"R1,R2",Resistor_SMD:R_1206_3216Metric, C26033
1.15k,R10,Resistor_SMD:R_0402_1005Metric, C29401
4.99k,R12,Resistor_SMD:R_0603_1608Metric, C23046
10k,"R13,R14",Resistor_SMD:R_0603_1608Metric,C25804
47k,"R17,R19,R22,R23,R24",Resistor_SMD:R_0402_1005Metric,C25792
0,R18,Resistor_SMD:R_0402_1005Metric,C17168
47,R20,Resistor_SMD:R_0402_1005Metric, C25118
2k2,R21,Resistor_SMD:R_0603_1608Metric, C4190
10k,R27,Resistor_SMD:R_0402_1005Metric,C25744
2.2k,R28,Resistor_SMD:R_0603_1608Metric, C4190
8.87k,"R3,R5",Resistor_SMD:R_0402_1005Metric,C36953
4.42k,R4,Resistor_SMD:R_0402_1005Metric,C52269
620,"R6,R8",Resistor_SMD:R_0402_1005Metric,C4961
294,R7,Resistor_SMD:R_0402_1005Metric,C270618
130,"R9,R11",Resistor_SMD:R_0402_1005Metric, C270649
TL1105CF160Q,S1,SamacSys_Parts:TL1105CF160Q,
STM32H743VITx,U2,Package_QFP:LQFP-100_14x14mm_P0.5mm,
REF3433IDBVR,U3,REF3433:REF3433IDBVR,
USBLC6-2SC6,U4,Package_TO_SOT_SMD:SOT-23-6,C7519
16MHz,Y1,Crystal:Crystal_SMD_3225-4Pin_3.2x2.5mm, C13738

## KiCad design CM4 Design/CM4/CM4.kicad_pcb

Board: 4 copper layers, 76.2 x 54.3 mm, 113 parts (27 on the bottom side), 59 nets.

Parts:
BT1: Battery_Cell; BatteryHolder_Keystone_3000_1x12mm
C1, C2, C3, C4: 100p; C_0402_1005Metric
C5: 10p; C_0402_1005Metric
C6, C7, C9: 10u; C_0805_2012Metric
C8: 100n; C_0805_2012Metric
C10: 10u x5R 25V; C_1210_3225Metric
C11: 22u x7R 10V; C_1210_3225Metric
C12: 1u; C_0805_2012Metric
C13, C47: 4.7u; CP_EIA-3216-18_Kemet-A
C14, C15, C16, C17, C18, C19, C20, C21, C22, C24, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C44, C50: 100n; C_0402_1005Metric
C23, C25: 1u; CP_EIA-3216-18_Kemet-A
C39, C42: 10u; C_0402_1005Metric
C40: 1u_X5R_0603; C_0603_1608Metric
C41: 220p; C_0402_1005Metric
C43, C46: 4.7u; C_0402_1005Metric
C45: 2.2u; C_0603_1608Metric
C48, C49: 12p; C_0402_1005Metric
C51, C52: 1.5p; C_0402_1005Metric
D1: SS14; D_SMA
D2: LED_Red; LED_0603_1608Metric
D3: LED; LED_0603_1608Metric
F1: Polyfuse; Fuse_1206_3216Metric
FB1: 600 @ 100MHz; L_0805_2012Metric
FB2: 100 @ 100 MHz; L_0603_1608Metric
FB3: 18 @100Mhz; L_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_ISO14580_Pad
IC1, IC2: OPA659IDBVR; SOT95P280X145-5N
IC3: LMH6643MAX_NOPB; SOIC127P600X175-8N
IC4: TPS65133DPDR; SON45P300X300X80-13N-D
IC5: TPS62111RSAT; QFN65P400X400X100-17N-D
IC6: STM32H747IIT6; QFP50P2600X2600X160-176N
J1: Conn_Coaxial; SMA_Samtec_SMA-J-P-H-ST-EM1_EdgeMount
J2: USB_C_Receptacle_USB2.0; TYPE-C-31-M-12
J3: SWDIO; PinHeader_2x05_P1.27mm_Vertical
J4: Micro_SD_Card; microSD_HC_Hirose_DM3AT-SF-PEJM5
J5: DJI UART; Molex_PicoBlade_53261-0371_1x03-1MP_P1.25mm_Horizontal
J6: Conn_01x02_Female; PinHeader_1x02_P2.54mm_Horizontal
L1, L2: 4.7u; L_Coilcraft_XxL4020
L3: 6.8u; L_TDK_SLF7032
L4: 2.2uH; L_0805_2012Metric
Module1: ComputeModule4; Raspberry-Pi-4-Compute-Module
Q1: AO3401A; SOT95P280X125-3N
R1: 44.2k; R_0402_1005Metric
R2: 66.5k; R_0402_1005Metric
R3: 6.34k; R_0402_1005Metric
R4: 35.7k; R_0402_1005Metric
R5: 34.8k; R_0402_1005Metric
R6, R19, R27: 10k; R_0402_1005Metric
R7, R9: 187; R_0402_1005Metric
R8, R10: 2.49k; R_0402_1005Metric
R11, R14: 100k; R_0603_1608Metric
R12, R13: 50k; R_0603_1608Metric
R15, R16: 5.1k; R_1206_3216Metric
R17: 1M; R_0805_2012Metric
R18, R20: 47; R_0402_1005Metric
R21: 2k2; R_0603_1608Metric
R22, R23, R24, R25, R26: 47k; R_0402_1005Metric
R28: 2.2k; R_0603_1608Metric
S1: TL1105CF160Q
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y2: 32.768KHz; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
/5V: C6.1, C8.1, C10.1, C12.1, FB1.2, IC4.7 (EN), IC4.11 (AVIN), IC4.12 (PVIN), IC5.2 (VIN_1), IC5.3 (VIN_2), IC5.4 (EN), IC5.8 (VINA), L1.1, Module1.77 (+5v_(Input)), Module1.79 (+5v_(Input)), Module1.81 (+5v_(Input)), Module1.83 (+5v_(Input)), Module1.85 (+5v_(Input)), Module1.87 (+5v_(Input))
/+3.3V: C11.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C40.1, C44.2, C45.2, D1.1 (K), D3.2 (A), FB2.1, FB3.1, IC3.8 (V+), IC5.10 (FB), IC6.7 (VDD_1), IC6.13 (VDD_2), IC6.25 (VDD_3), IC6.44 (VDD_4), IC6.46 (PA3), IC6.48 (VDD_5), IC6.65 (VDD_6), IC6.71 (VDD_7), IC6.84 (VDD_8), IC6.92 (VDD_9), IC6.99 (VDD_10), IC6.101 (VCAPDSI), IC6.102 (VDD12DSI_1), IC6.108 (VDD12DSI_2), IC6.113 (VDD_11), IC6.120 (VDD50USB), IC6.121 (VDD33USB), IC6.126 (VDD_12), IC6.136 (VDD_13), IC6.152 (VDD_14), IC6.160 (VDD_15), IC6.176 (VDD_16), J3.1, J4.4 (VDD), L3.2, R14.1, R17.2, R19.1, R22.2, R23.2, R24.2, R25.2, R26.2
/CM4_GPIO/GPIO_14_TX: J5.2, Module1.55 (GPIO14)
/CM4_GPIO/GPIO_15_RX: J5.1, Module1.51 (GPIO15)
/H7MCU/+3.3VA: C25.1, C26.2, FB2.2, IC6.40 (VDDA), R18.2
/H7MCU/BOOT0: IC6.167 (BOOT0), R27.1
/H7MCU/HSE_IN: C49.1, IC6.31 (PH0-OSC_IN), Y1.1
/H7MCU/HSE_OUT: IC6.32 (PH1-OSC_OUT), R20.1
/H7MCU/LED_STAT: D2.2 (A), IC6.43 (PA2)
/H7MCU/NRST: C50.2, IC6.33 (NRST), J3.10, S1.1, S1.2
/H7MCU/OSC_IN: C51.2, IC6.10 (PC14-OSC32_IN), Y2.2
/H7MCU/OSC_OUT: C52.2, IC6.11 (PC15-OSC32_OUT), Y2.1
/H7MCU/SDMMC_CK: IC6.142 (PC12), J4.5 (CLK)
/H7MCU/SDMMC_CMD: IC6.145 (PD2), J4.3 (CMD), R24.1
/H7MCU/SDMMC_D0: IC6.124 (PC8), J4.7 (DAT0), R25.1
/H7MCU/SDMMC_D1: IC6.125 (PC9), J4.8 (DAT1), R26.1
/H7MCU/SDMMC_D2: IC6.140 (PC10), J4.1 (DAT2), R22.1
/H7MCU/SDMMC_D3: IC6.141 (PC11), J4.2 (DAT3/CD), R23.1
/H7MCU/SWCLK: IC6.138 (PA14), J3.4
/H7MCU/SWDIO: IC6.132 (PA13), J3.2
/H7MCU/SWO: IC6.162 (PB3), J3.6
/H7MCU/VCAP1: C42.1, C43.1, C46.1, C47.1, IC6.17 (VFBSMPS), IC6.80 (VCAP_1), IC6.82 (VDDLDO_1), IC6.133 (VCAP_2), IC6.135 (VDDLDO_2), IC6.175 (VDDLDO_3), L4.1
/H7MCU/VDDSMPS: C39.2, FB3.2, IC6.16 (VDDSMPS)
/H7MCU/VLXSMPS: C41.1, IC6.15 (VLXSMPS), L4.2
/H7MCU/VREF+: C23.1, C24.2, IC6.39 (VREF+), R18.1
/Power/PG: IC5.13 (PG), R17.1
/Power/SW: IC5.14 (SW_1), IC5.15 (SW_2), L3.1
/STM32_3_RX: IC6.79 (PB11), Module1.31 (GPIO12)
/STM32_3_TX: IC6.78 (PB10), Module1.28 (GPIO13)
/USB_D+: IC6.131 (PA12), Module1.105 (USB2_P)
/USB_D-: IC6.130 (PA11), Module1.103 (USB2_N)
/VNEG: C9.1, IC1.2 (-VS), IC2.2 (-VS), IC4.9 (VNEG)
/VPOS: C7.1, IC1.5 (+VS), IC2.5 (+VS), IC4.3 (VPOS)
/v_DIV_OUT: C5.2, IC3.1 (OUT_A), IC6.36 (PC2_C), J6.1, R12.1
GND: BT1.2 (-), C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.1, C25.2, C26.1, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.1, C40.2, C41.2, C42.2, C43.2, C44.1, C45.1, C46.2, C47.2, C50.1, C51.1, C52.1, IC3.4 (V-), IC4.2 (PGND), IC4.4 (GND_1), IC4.5 (AGND), IC4.6 (GND_2), IC4.8 (GND_3), IC4.13 (EP), IC5.1 (PGND_1), IC5.5 (SYNC), IC5.6 (LBO), IC5.7 (LBI), IC5.9 (AGND), IC5.11 (GND_1), IC5.12 (GND_2), IC5.16 (PGND_2), IC5.17 (EP), IC6.6 (VSS_1), IC6.12 (VSS_2), IC6.14 (VSSSMPS), IC6.24 (VSS_3), IC6.38 (VSSA), IC6.45 (VSS_4), IC6.47 (VSS_5), IC6.64 (VSS_6), IC6.70 (VSS_7), IC6.81 (VSS_8), IC6.83 (VSS_9), IC6.93 (VSS_10), IC6.100 (VSS_11), IC6.105 (VSSDSI_1), IC6.109 (VSSDSI_2), IC6.112 (VSS_12)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
unnamed: BT1.1 (+), D1.2 (A), IC6.8 (VBAT)
unnamed: C1.1, IC1.3 (POS), R3.2
unnamed: C1.2, C3.1, R1.2, R5.1
unnamed: C2.1, IC2.3 (POS), R6.2
unnamed: C2.2, C4.1, R2.2, R4.1
unnamed: C5.1, IC3.2 (-IN_A), R11.2, R12.2
unnamed: C48.1, C49.2, Y1.2, Y1.4
unnamed: C48.2, R20.2, Y1.3
unnamed: D2.1 (K), R21.1
unnamed: D3.1 (K), R28.2
unnamed: F1.2, Q1.3
unnamed: FB1.1, Q1.2
unnamed: IC1.4 (NEG), R7.1, R8.2
unnamed: IC2.1 (OUTPUT), R2.1, R5.2, R10.1
unnamed: IC2.4 (NEG), R9.1, R10.2
unnamed: IC3.3 (+IN_A), R13.1, R14.2
unnamed: IC4.1 (SWP), L1.2
unnamed: IC4.10 (SWN), L2.1
unnamed: IC6.174 (PDR_ON), R19.2
unnamed: J1.1 (In), R4.2
unnamed: J2.A5 (CC1), R15.1
unnamed: J2.B5 (CC2), R16.1
P_AMP_OUT: IC1.1 (OUTPUT), R1.1, R8.1, R13.2
VCC: F1.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
