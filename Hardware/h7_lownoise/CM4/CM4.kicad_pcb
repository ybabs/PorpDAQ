# Repository ybabs/PorpDAQ (continued)

## KiCad design Hardware/board_100pin/F7_100pin/F7_100pin.kicad_pcb

Parts:
C1, C2: 2.2u; C_1206_3216Metric
C3, C4, C5, C6: 100p; C_0402_1005Metric
C7, C8: 4.3p; C_0402_1005Metric
C9: 10p; C_0402_1005Metric
C10, C11: 10u; C_0603_1608Metric
C12, C13, C15: 10u; C_0805_2012Metric
C14: 100n; C_0805_2012Metric
C16: 4.7u; CP_EIA-3216-18_Kemet-A
C17, C18, C19, C20, C21, C23, C25, C26: 100n; C_0402_1005Metric
C22, C24: 1u; CP_EIA-3216-18_Kemet-A
D1: B5819W; D_SOD-123
D2: Red_LED; LED_0603_1608Metric
D4: Green_LED; LED_0603_1608Metric
F1: 500mA; Fuse_0603_1608Metric
FB1: 100 @ 100 MHz; L_0603_1608Metric
FB2: 100 @ 100 Mhz; L_0603_1608Metric
H1: M_HolePad; MountingHole_3.2mm_M3_Pad_Via
H2, H3, H4: MHole_Pad; MountingHole_3.2mm_M3_Pad_Via
IC1, IC2: OPA659IDBVR; SOT95P280X145-5N; Manufacturer_Part_Number OPA659IDBVR; Mouser Part Number 595-OPA659IDBVR
IC3: LMH6643MAX_NOPB; SOIC127P600X175-8N; Manufacturer_Part_Number LMH6643MAX/NOPB; Mouser Part Number 926-LMH6643MAX/NOPB
IC4: TPS65133DPDR; SON45P300X300X80-13N-D; Manufacturer_Part_Number TPS65133DPDR; Mouser Part Number 595-TPS65133DPDR
J1: SMA Edge; 142-0701-851; Manufacturer_Part_Number 142-0701-851; Mouser Part Number 530-142-0701-851
J2: Pre-Amp; PinHeader_1x02_P2.54mm_Vertical
J3: UART; PinHeader_1x04_P2.54mm_Vertical
J4: USB_B_Micro; USB_Micro-B_GCT_USB3076-30-A
J5: Filter; PinHeader_1x02_P2.54mm_Vertical
J6: 3V3; PinHeader_1x02_P2.54mm_Vertical
J7: SWDIO; PinHeader_2x05_P1.27mm_Vertical
J8: Micro_SD_Card; microSD_HC_Hirose_DM3AT-SF-PEJM5
L1, L2: 4.7u; L_Coilcraft_XxL4020
R1: 44.2k; R_0402_1005Metric
R2: 66.5k; R_0402_1005Metric
R3: 35.7k; R_0402_1005Metric
R4: 34.8k; R_0402_1005Metric
R5: 6.34k; R_0402_1005Metric
R6, R13: 10k; R_0402_1005Metric
R7, R9: 187; R_0402_1005Metric
R8, R10: 2.49k; R_0402_1005Metric
R11, R15: 50k; R_0603_1608Metric
R12, R24: 2k2; R_0402_1005Metric
R14, R16: 100k; R_0603_1608Metric
R19, R20, R21, R22, R23: 47k; R_0402_1005Metric
R25: 0; R_0402_1005Metric
S1: TL1105CF160Q; Manufacturer_Part_Number TL1105CF160Q; Mouser Part Number 612-TL1105C
U1: AMS1117-3.3; SOT-223-3_TabPin2
U2: STM32F746VGTx; LQFP-100_14x14mm_P0.5mm
X1: NX3325GD; RESC3226X100N

Connections:
3V3: C11.1, C16.1, C17.2, C18.2, C19.2, C20.2, C21.2, D4.2 (A), FB2.1, IC3.8 (V+), J3.3, J6.1, J7.1, J8.4 (VDD), R14.1, R19.2, R20.2, R21.2, R22.2, R23.2, U1.2 (VO), U2.6 (VBAT), U2.11 (VDD), U2.27 (VDD), U2.50 (VDD), U2.75 (VDD), U2.100 (VDD)
3V3A: C24.1, C25.2, FB2.2, R25.2, U2.21 (VDDA)
BOOT0: R13.2, U2.94 (BOOT0)
GND: C1.2, C2.2, C5.2, C6.2, C7.2, C8.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.1, C18.1, C19.1, C20.1, C21.1, C22.2, C23.1, C24.2, C25.1, C26.1, H1.1, H2.1, H3.1, H4.1, IC3.4 (V-), IC4.2 (PGND), IC4.4 (GND_1), IC4.5 (AGND), IC4.6 (GND_2), IC4.8 (GND_3), IC4.13 (EP), J1.1, J1.3, J2.2, J3.4, J4.4 (ID), J4.5 (GND), J4.6 (Shield), J5.2, J6.2, J7.3, J7.5, J7.9, J8.6 (VSS), J8.9 (SHIELD), L2.2, R5.1, R6.1, R7.2, R9.2, R12.1, R13.1, R16.1, R24.1, S1.3, S1.4, U1.1 (GND), U2.10 (VSS), U2.19 (VSSA), U2.26 (VSS), U2.49 (VSS), U2.74 (VSS), U2.99 (VSS)
NRST: C26.2, J7.10, S1.1, S1.2, U2.14 (NRST)
unnamed: C1.1, U2.48 (VCAP_1)
unnamed: C2.1, U2.73 (VCAP_2)
unnamed: C3.1, IC1.3 (POS), R5.2
unnamed: C3.2, C5.1, R1.2, R4.1
unnamed: C4.1, IC2.3 (POS), R6.2
unnamed: C4.2, C6.1, R2.2, R3.1
unnamed: C7.1, U2.12 (PH0), X1.2
unnamed: C8.1, U2.13 (PH1), X1.1
unnamed: C9.1, IC3.2 (-IN_A), R11.2, R16.2
unnamed: C10.1, FB1.1, U1.3 (VI)
unnamed: D1.1 (K), F1.1
unnamed: D2.1 (K), R12.2
unnamed: D2.2 (A), U2.46 (PB10)
unnamed: D4.1 (K), R24.2
unnamed: F1.2, FB1.2
unnamed: IC1.4 (NEG), R7.1, R8.2
unnamed: IC2.1 (OUTPUT), R2.1, R4.2, R10.1
unnamed: IC2.4 (NEG), R9.1, R10.2
unnamed: IC3.3 (+IN_A), R14.2, R15.1
unnamed: IC4.1 (SWP), L1.2
unnamed: IC4.10 (SWN), L2.1
unnamed: J1.2, R3.2
P_AMP_OUT: IC1.1 (OUTPUT), J2.1, R1.1, R8.1, R15.2
SWCLK: J7.4, U2.76 (PA14)
SWDIO: J7.2, U2.72 (PA13)
SWO: J7.6, U2.89 (PB3)
USART_6_RX: J3.1, U2.64 (PC7)
USART_6_TX: J3.2, U2.63 (PC6)
VCC: C12.1, C14.1, D1.2 (A), IC4.7 (EN), IC4.11 (AVIN), IC4.12 (PVIN), J4.1 (VBUS), L1.1
VNEG: C15.1, IC1.2 (-VS), IC2.2 (-VS), IC4.9 (VNEG)
VPOS: C13.1, IC1.5 (+VS), IC2.5 (+VS), IC4.3 (VPOS)
VREF+: C22.1, C23.2, R25.1, U2.20 (VREF+)
uSD_CLK: J8.5 (CLK), U2.80 (PC12)
uSD_CMD: J8.3 (CMD), R21.1, U2.83 (PD2)
uSD_D0: J8.7 (DAT0), R22.1, U2.65 (PC8)
uSD_D1: J8.8 (DAT1), R23.1, U2.66 (PC9)
uSD_D2: J8.1 (DAT2), R19.1, U2.78 (PC10)
uSD_D3: J8.2 (DAT3/CD), R20.1, U2.79 (PC11)
v_DIV_OUT: C9.2, IC3.1 (OUT_A), J5.1, R11.1, U2.25 (PA3)

Notes on the sheet:
RESET BUTTON
Connectors
PWR_LED
PRE-AMP
Mounting Holes
INPUT VOLTAGE REGULATOR
SD CARD
BIASED PRE_AMP OUTPUT
USB-POWER

Board: 4 copper layers, 69.8 x 45.7 mm, 77 parts (0 on the bottom side), 44 nets.

File Hardware/board_100pin/Orders/F7_100pin_BOM_JLC.xlsx:

Designator | Quantity | Value | Footprint | LCSC Part #
C2, C1, | 2 | 2.2u | 1206 | C50254
C6, C4, C5, C3, | 4 | 100p | 402 | C1546
C7, C8, | 2 | 4.3p | 402 | C159803
C9, | 1 | 10p | 402 | C32949
C10, C11, | 2 | 10u | 603 | C19702
C12, C13, C15, | 3 | 10u | 805
C14, | 1 | 100n | 805
C16, | 1 | 4.7u | EIA-3216-18 | C7187
C24, C22, | 2 | 1u | EIA-3216-18 | C7176
C26, C25, C23, C17, C18, C19, C20, C21, | 8 | 100n | 402 | C1525
D1, | 1 | B5819W | SOD-123 | C8598
D2, | 1 | Red_LED | 603 | C2286
D4, | 1 | Green_LED | 603 | C72043
F1, | 1 | 500mA | 603
FB1, | 1 | 100 @ 100 MHz | 603
FB2, | 1 | 100 @ 100 Mhz | 603
IC2, IC1, | 2 | OPA659IDBVR | SOT-23
IC3, | 1 | LMH6643MAX_NOPB | SOIC-8
IC4, | 1 | TPS65133DPDR | 12-WSON | C134100
J1, | 1 | SMA Edge
J2, | 1 | Pre-Amp | Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical
J3, | 1 | UART | Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical
J4, | 1 | USB_B_Micro | USB_B_Micro
J5, | 1 | Filter | Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical
J6, | 1 | 3V3 | Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical
J7, | 1 | SWDIO | Connector_PinHeader_1.27mm:PinHeader_2x05_P1.27mm_Vertical
J8, | 1 | Micro_SD_Card | Connector_Card:microSD_HC_Hirose_DM3AT-SF-PEJM5 | C114218
L1, L2, | 2 | 4.7u | Inductor_SMD:L_Coilcraft_XxL4020
R1, | 1 | 44.2k | 402 | C25895
R2, | 1 | 66.5k | 402 | C29381
R3, | 1 | 35.7k | 402 | C26975
R4, | 1 | 34.8k | 402 | C47493
R5, | 1 | 6.34k | 402 | C45013
R6, R13, | 2 | 10k | 402 | C25744
R9, R7, | 2 | 187 | 402 | C39887
R10, R8, | 2 | 2.49k | 402 | C25884
R15, R11, | 2 | 50k | 603 | C23184
R16, R14, | 2 | 100k | 603 | C25803
R20, R21, R22, R23, R19, | 5 | 47k | 402 | C25792
R24, R12, | 2 | 2k2 | 402 | C25879
R25, | 1 | 0 | 402 | C17168
S1, | 1 | TL1105CF160Q | SamacSys_Parts:TL1105CF160Q | C273468
U1, | 1 | AMS1117-3.3 | SOT223-3 | C6186
U2, | 1 | STM32F746VGTx | LQFP-100_14.0x14.0x0.5P | C87664
X1, | 1 | NX3325GD | SamacSys_Parts:RESC3226X100N

## KiCad design Hardware/board_final/hydrophone_stm32_board.kicad_pcb

Parts:
C1, C3: 4.3p; C_0402_1005Metric
C2: 4.7u; CP_EIA-3216-18_Kemet-A
C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C35, C37, C41: 100n; C_0402_1005Metric
C30, C33: 2.2u; C_1206_3216Metric
C31, C32, C38, C40: 10u; C_0603_1608Metric
C34, C36: 1u; CP_EIA-3216-18_Kemet-A
C39: 100n; C_0603_1608Metric
C42, C46: 1.3n; C_0603_1608Metric
C43, C47: 1.1n; C_0603_1608Metric
C44, C48: 1.5n; C_0603_1608Metric
C45, C49: 1n; C_0603_1608Metric
D1: Green LED; LED_0603_1608Metric
D2: B5819W; D_SOD-123
D3: Red LED; LED_0603_1608Metric
F1: 500mA; Fuse_0603_1608Metric
FB1, FB2: 100 @ 100 MHz; L_0603_1608Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
IC1: AD8031ARZ; SOIC127P600X175-8N; Manufacturer_Part_Number AD8031ARZ; Mouser Part Number 584-AD8031ARZ
J1, J3: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J2: Conn_02x05_Odd_Even; PinHeader_2x05_P1.27mm_Vertical_SMD
J4: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J5: Micro_SD_Card; microSD_HC_Hirose_DM3AT-SF-PEJM5
J6: 142-0701-851; Manufacturer_Part_Number 142-0701-851; Mouser Part Number 530-142-0701-851
J7: Conn_01x02_Female; PinHeader_1x02_P2.54mm_Vertical
R1: 2k2; R_0603_1608Metric
R2, R6, R7, R8, R9: 47k; R_0402_1005Metric
R3: 0; R_0402_1005Metric
R4, R5, R14, R15: 10k; R_0402_1005Metric
R11: 512; R_0603_1608Metric
R16: 4.99k; R_0402_1005Metric
R17: 4.52k; R_0402_1005Metric
R18: 4.39k; R_0402_1005Metric
R19: 11k; R_0402_1005Metric
R20: 10.4k; R_0402_1005Metric
R21: 418; R_0402_1005Metric
R22: 406; R_0402_1005Metric
R23: 1.02k; R_0402_1005Metric
R24: 966; R_0402_1005Metric
R25: 558; R_0402_1005Metric
R26: 541; R_0402_1005Metric
R27: 106; R_0402_1005Metric
R28: 100; R_0402_1005Metric
S1: TL1105CF160Q; Manufacturer_Part_Number TL1105CF160Q; Mouser Part Number 612-TL1105C
U1: AMS1117-3.3; SOT-223-3_TabPin2
U2: STM32F746ZGT6; LQFP-144_20x20mm_P0.5mm
U3, U4, U5, U6: ADA4807-1; SOT-23-6
Y1: Crystal; RESC3226X100N

Connections:
+3.3VA: C36.1, C37.1, FB2.1, R3.2, U2.33 (VDDA)
+3V3: C2.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C32.1, D1.2 (A), FB2.2, J2.1, J3.1, J4.3, J5.4 (VDD), R2.2, R5.2, R6.2, R7.2, R8.2, R9.2, R14.2, U1.2 (VO), U2.6 (VBAT), U2.17 (VDD), U2.30 (VDD), U2.39 (VDD), U2.52 (VDD), U2.62 (VDD), U2.72 (VDD), U2.84 (VDD), U2.95 (VDDUSB), U2.108 (VDD), U2.121 (VDD), U2.131 (VDD), U2.144 (VDD), U3.6 (V+), U4.6 (V+), U5.6 (V+), U6.6 (V+)
BOOT0: R4.2, U2.138 (BOOT0)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.1, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.1, C39.1, C40.1, C41.1, H1.1, H2.1, H3.1, H4.1, IC1.4 (-VS), J1.2, J2.3, J2.5, J2.9, J3.2, J4.4, J5.6 (VSS), J5.9 (SHIELD), J6.1, J6.3, J7.2, R1.2, R4.1, R11.1, R15.1, S1.2, S1.3, U1.1 (GND), U2.16 (VSS), U2.31 (VSSA), U2.38 (VSS), U2.51 (VSS), U2.61 (VSS), U2.83 (VSS), U2.94 (VSS), U2.107 (VSS), U2.120 (VSS), U2.130 (VSS), U3.2 (V-), U4.2 (V-), U5.2 (V-), U6.2 (V-)
NRST: C27.2, J2.10, S1.1, S1.4, U2.25 (NRST)
unnamed: C1.1, U2.23 (PH0), Y1.1
unnamed: C3.1, U2.24 (PH1), Y1.2
unnamed: C30.1, U2.71 (VCAP_1)
unnamed: C31.1, FB1.1, U1.3 (VI)
unnamed: C33.1, U2.106 (VCAP_2)
unnamed: C40.2, C41.2, IC1.3 (+IN), R14.1, R15.2
unnamed: C42.1, R17.2, R22.2, U3.1
unnamed: C42.2, C46.2, R21.1, R25.2
unnamed: C43.1, R18.2, R23.2, U4.1
unnamed: C43.2, C47.2, R22.1, R26.2
unnamed: C44.1, R19.2, R24.2, U5.1
unnamed: C44.2, C48.2, R23.1, R27.2
unnamed: C45.2, C49.2, R24.1, R28.2
unnamed: C46.1, R17.1, U3.4 (-)
unnamed: C47.1, R18.1, U4.4 (-)
unnamed: C48.1, R19.1, U5.4 (-)
unnamed: C49.1, R20.1, U6.4 (-)
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), F1.1
unnamed: D3.1 (K), R11.2
unnamed: D3.2 (A), U2.69 (PB10)
unnamed: F1.2, FB1.2
unnamed: IC1.2 (-IN), R16.2
unnamed: J6.2, R21.2
PDR_ON: R5.1, U2.143 (PDR_ON)
SWCLK: J2.4, U2.109 (PA14)
SWDIO: J2.2, U2.105 (PA13)
SWO: J2.6, U2.133 (PB3)
USART6_RX: J4.2, U2.97 (PC7)
USART6_TX: J4.1, U2.96 (PC6)
VCC: D2.2 (A), J1.1
VDIV: C38.2, C39.2, IC1.6 (OUT), R16.1, R25.1, R26.1, R27.1, R28.1, U3.3 (+), U4.3 (+), U5.3 (+), U6.3 (+)
VREF+: C34.1, C35.1, R3.1, U2.32 (VREF+)
V_OUT: C45.1, J7.1, R20.2, U2.22 (PF10), U6.1
uSD_CLK: J5.5 (CLK), U2.113 (PC12)
uSD_CMD: J5.3 (CMD), R8.1, U2.116 (PD2)
uSD_D0: J5.7 (DAT0), R2.1, U2.98 (PC8)
uSD_D1: J5.8 (DAT1), R9.1, U2.99 (PC9)
uSD_D2: J5.1 (DAT2), R6.1, U2.111 (PC10)
uSD_D3: J5.2 (DAT3/CD), R7.1, U2.112 (PC11)

Notes on the sheet:
Input Voltage Regulator
RESET BUTTON
PREAMP VOLTAGE DIVIDER
PREAMP
PWR_LED
Connectors
MCU
Mounting Holes

Board: 4 copper layers, 98 parts (0 on the bottom side), 45 nets, no tracks yet.

File Hardware/board_final/BOM.csv:

Designator,Quantity,Value,footprint,LCSC Part #,Farnell Part #
U1,1,AMS1117-3.3,SOT223-3,C6186,3007498
FB1,1,100 @ 100 MHz,0603,,
F1,1,500mA,0603,,
D2,1,B5819W,SOD-123,,
C31,1,10u,0603,C19702,1867954
C32,1,10u,0603,C19702,1867954
FB2,1,100 @ 100 MHz,0603,,
C36,1,1u,EIA-3216-18,C7176,145706
C37,1,100n,0402,C1525,1867948
C18,1,100n,0402,C1525,1867948
C19,1,100n,0402,C1525,1867948
C20,1,100n,0402,C1525,1867948
C21,1,100n,0402,C1525,1867948
C22,1,100n,0402,C1525,1867948
C23,1,100n,0402,C1525,1867948
C24,1,100n,0402,C1525,1867948
C25,1,100n,0402,C1525,1867948
C26,1,100n,0402,C1525,1867948
C16,1,100n,0402,C1525,1867948
C17,1,100n,0402,C1525,1867948
C7,1,100n,0402,C1525,1867948
C8,1,100n,0402,C1525,1867948
C9,1,100n,0402,C1525,1867948
C10,1,100n,0402,C1525,1867948
C11,1,100n,0402,C1525,1867948
C12,1,100n,0402,C1525,1867948
C13,1,100n,0402,C1525,1867948
C14,1,100n,0402,C1525,1867948
C15,1,100n,0402,C1525,1867948
C5,1,100n,0402,C1525,1867948
C6,1,100n,0402,C1525,1867948
C4,1,100n,0402,C1525,1867948
C3,1,1u,EIA-3216-18,C7176,145706
C2,1,4.7u,EIA-3216-18, C161817,1641479
C1,1,4.7u,EIA-3216-18, C161817,1641479
HSE1,1,25MHz,Crystal:Crystal_SMD_3225-4Pin_3.2x2.5mm, C9006,
R2,1,100,0402, C25076,1469672
C28,1,18p,0402,C1549,1740572
C29,1,18p,0402,C1549,1740572
R4,1,10k,0402, C25744,
C30,1,2.2u,1206, C50254,2887204
C33,1,2.2u,1206, C50254,2887204
C34,1,1u,EIA-3216-18,C7176,145706
C35,1,100n,0402,C1525,1867948
R3,1,0,0402,C17168,
R5,1,10k,0402, C25744,
D3,1,Red LED,0603, C2286,
C27,1,100n,0402,C1525,1867948
R11,1,512,0603,C51224,
U2,1,STM32F746ZGT6,Package_QFP:LQFP-144_20x20mm_P0.5mm, C90750,
R15,1,10k,0402, C25744,
R14,1,10k,0402, C25744,
C41,1,100n,0402,C1525,1867948
C40,1,10u,0603,C19702,1867954
C38,1,10u,0603,C19702,1867954
C39,1,100n,0603, C14663,
R16,1,4.99k,0402, C25903,
J6,1,142-0701-851,SamacSys_Parts:142-0701-851,,
R21,1,418,0402,,
R25,1,558,0402, C67558,
R17,1,4.52k,0402,,
C46,1,1.3n,0603,,
C42,1,1.3n,0603,,
U3,1,ADA4807-1,SOT23-6,,
R22,1,406,0402,,
R26,1,541,0402,,
R18,1,4.39k,0402,,
C47,1,1.1n,0603,,
C43,1,1.1n,0603,,
U4,1,ADA4807-1,SOT-23-6,,
R23,1,1.02k,0402,,
R27,1,106,0402,,
R19,1,11k,0402,,
C48,1,1.5n,0603,,
C44,1,1.5n,0603,,
U5,1,ADA4807-1,SOT-23-6,,
R24,1,966,0402,,
R28,1,100,0402,,
R20,1,10.4k,0402,,
C49,1,1n,0603, C1588,
C45,1,1n,0603, C1588,
U6,1,ADA4807-1,SOT-23-6,,
J5,1,PJS008-2003-1,SamacSys_Parts:PJS00820031,,
R13,1,0,0402,,
R12,1,NA,0402,,
R6,1,47k,0402, C25792,
R7,1,47k,0402, C25792,
R8,1,47k,0402, C25792,
R9,1,47k,0402, C25792,
R10,1,47k,0402, C25792,
IC1,1,AD8031ARZ,SamacSys_Parts:SOIC127P600X175-8N,,
R1,1,2k2,0603, C4190,
D1,1,Green LED,0603, C72043,
S1,1,TL1105CF160Q,SamacSys_Parts:TL1105CF160Q,,
